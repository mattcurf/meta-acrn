require linux-acrn-common.inc

PV = "4.19.32-acrn"

SRC_URI += "file://defconfig \
"
